# Keil uVision project ServoLifter.uvproj, settings and files
target ServoLifter Configuration (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: ServoLifter Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F051x8
  c misc: --C99
  c include: ..\..\Drivers\CMSIS\Include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0; ; ..\..\Drivers\STM32F0xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0; ; ..\..\Drivers\STM32F0xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0; ; ..\..\Drivers\STM32F0xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0; ..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\STM32F0xx_HAL_Driver\Inc; ..\..\Inc; ..\..\Inc; ; ..\..\Drivers\STM32F0xx_HAL_Driver\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ; ..\..\Drivers\CMSIS\Include; ; ..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include; ..\..\Inc; ; ..\..\Drivers\STM32F0xx_HAL_Driver\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ; ..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include; ..\..\Inc; ; ..\..\Drivers\STM32F0xx_HAL_Driver\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ; ..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include
  asm include: ..\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/User
    ../../Src/: gpio.c main.c stm32f0xx_it.c freertos.c tim.c command.c usart.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c
  group Middlewares/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group Application/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f051x8.s
